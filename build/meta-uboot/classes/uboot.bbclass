# Copyright (c) 2025-2026 EDGEMTech SA

# Class for building U-boot in infrabase

IB_UBOOT_PATH = "${IB_DIR}/u-boot"

# Generated by the U-Boot build next to the real sources, so updiff would take
# them for new files. include/config.h is named by path: arch/*/include/asm/
# carries real config.h files.

IB_UPDIFF_EXCLUDE ??= "u_boot_logo.S bmp_logo.h bmp_logo_data.h \
    helloworld_efi.S generated_defconfig include/config.h"


